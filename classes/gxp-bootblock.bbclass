LICENSE = "CLOSED"

addtask deploy before do_build after do_compile

