KBRANCH:proliant-yocto = "standard/base"

KMACHINE:proliant-yocto ?= "proliant"

COMPATIBLE_MACHINE:proliant-yocto = "proliant-yocto"
