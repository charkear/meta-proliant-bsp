inherit gxp-bootblock
inherit gxp2-bootblock-t280