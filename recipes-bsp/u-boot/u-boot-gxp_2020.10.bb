require u-boot-gxp.inc
require ../../meta/recipes-bsp/u-boot/u-boot.inc

DEPENDS += "bc-native dtc-native"

